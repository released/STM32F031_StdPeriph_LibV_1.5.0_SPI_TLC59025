# IAR project Project.ewp, settings and files
configuration STM32F030 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\inc; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\RTOS; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\include; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F030.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f030_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f072.s startup_stm32f091.s
    ../src/: system_stm32f0xx.c
  group RTOS
    ../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../src/: App_Task.c Hw_config.c macro.c main.c stm32f0xx_it.c stm32f0xx_VL6180.c
